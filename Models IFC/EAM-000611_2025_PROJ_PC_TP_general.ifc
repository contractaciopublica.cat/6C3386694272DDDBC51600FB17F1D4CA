Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0]
File name: topografia-territorial-v1r0-full251158-2023.ifc
Time: 2025-05-14T18:44:06
Written by: FME 2022.2.2.0

# IfcSite, RTT
Description: ICGC Referencial topogràfic territorial; LongName: Referencial topogràfic territorial

# IfcBuilding, full251158
Description: ICGC topografia-territorial full251158; LongName: full251158

# IfcBuildingStorey (41)
In: full251158
Name | LongName
[xem] xemeneia | xemeneia
[tpn] tauler de pont | tauler de pont
[tpl] terraplè | terraplè
[tap] mur, tàpia | mur, tàpia
[res] resclosa | resclosa
[pub] divisió de parcel·les d'urbanitzacions | divisió de parcel·les d'urbanitzacions
[pon] pontarró | pontarró
[pis] piscina | piscina
[mco] mur de contenció | mur de contenció
[mcs] pista condicionada per a l'exercici de diversos esports | pista condicionada per a l'exercici de diversos esports
[ins] recinte d'inst. industrial | recinte d'inst. industrial
[ind] indústria | indústria
[flu] curs fluvial | curs fluvial
[pja] recinte de prats, jardins, arbrat i instal·lacions per a l'esbarjo | recinte de prats, jardins, arbrat i instal·lacions per a l'esbarjo
[esr] esplanada amb revestiment | esplanada amb revestiment
[esp] recinte d'inst. esportiva | recinte d'inst. esportiva
[esn] esplanada sense revestiment | esplanada sense revestiment
[emb] embarcador | embarcador
[ele] torre elèctrica | torre elèctrica
[hiv] hivernacle | hivernacle
[mob] moll, espigó d'obra | moll, espigó d'obra
[com] torre de comunicacions | torre de comunicacions
[cns] construcció | construcció
[cem] recinte de cementiri | recinte de cementiri
[lpn] lateral de pont | lateral de pont
[ill] illa urbanitzada | illa urbanitzada
[bsc] bosc | bosc
[bas] bassa | bassa
[can] canal, rec, séquia | canal, rec, séquia
[aga] agrupació d'arbres | agrupació d'arbres
[veg] tanca de vegetació | tanca de vegetació
[edi] edificació | edificació
[mol] moll, espigó d'acumulació de blocs de pedra o formigó | moll, espigó d'acumulació de blocs de pedra o formigó
[abo] abocador | abocador
[fil] filat | filat
[sol] terreny | terreny
[dmt] desmunt | desmunt
[prt] parterre | parterre
[dip] dipòsit cobert | dipòsit cobert
[ped] pedrera, mina a cel obert | pedrera, mina a cel obert
[fut] pista d'un camp de futbol | pista d'un camp de futbol

# IfcBuildingElementProxy (2425)
ACAT_Identificacio - ACAT_I4-Subsistema: EN; ACAT_I5-FontInformacio: Cartografia 1:5000 ICGC
Name | In | Description = ICGC_A11_TipusDescripcio = ACAT_I3-TipusNom | ICGC_A10_Tipus | ACAT_I1-CodiGuBIMclass | ACAT_I2-DescripcioGuBIMclass
xem | [xem] xemeneia | xemeneia | xem | 00.20.20 | Elements d'entorn urbà preexistent | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric
xem | [xem] xemeneia | xemeneia | xem | 00.20.10 | Edificacions colindants preexistents
40 x tpn | [tpn] tauler de pont | tauler de pont | tpn | 00.20.20 | Elements d'entorn urbà preexistent | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric
tpn | [tpn] tauler de pont | tauler de pont | tpn | 00.20.20 | Elements d'entorn urbà preexistent | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Pont de la Carretera Nacional; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: tauler de pont; ACAT_L2-DescripcioLocalitzacio: Pont de la Carretera Nacional
tpn | [tpn] tauler de pont | tauler de pont | tpn | 00.20.20 | Elements d'entorn urbà preexistent | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Pont Penjat; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: tauler de pont; ACAT_L2-DescripcioLocalitzacio: Pont Penjat
2 x tpn | [tpn] tauler de pont | tauler de pont | tpn | 00.20.20 | Elements d'entorn urbà preexistent | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Pont de l'Autopista; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: tauler de pont; ACAT_L2-DescripcioLocalitzacio: Pont de l'Autopista
40 x tpl | [tpl] terraplè | terraplè | tpl | 00.20.20 | Elements d'entorn urbà preexistent
97 x tap | [tap] mur, tàpia | mur, tàpia | tap | 00.20.20 | Elements d'entorn urbà preexistent
res | [res] resclosa | resclosa | res | 00.20.20 | Elements d'entorn urbà preexistent | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_A40_Entorn: gen; ICGC_A41_EntornDescripcio: cas genèric
35 x pub | [pub] divisió de parcel·les d'urbanitzacions | divisió de parcel·les d'urbanitzacions | pub | 00.20.20 | Elements d'entorn urbà preexistent
157 x pon | [pon] pontarró | pontarró | pon | 00.20.20 | Elements d'entorn urbà preexistent
44 x pis | [pis] piscina | piscina | pis | 00.20.20 | Elements d'entorn urbà preexistent
88 x mco | [mco] mur de contenció | mur de contenció | mco | 00.20.20 | Elements d'entorn urbà preexistent
19 x mcs | [mcs] pista condicionada per a l'exercici de diversos esports | pista condicionada per a l'exercici de diversos esports | mcs | 00.20.20 | Elements d'entorn urbà preexistent
3 x ins | [ins] recinte d'inst. industrial | recinte d'inst. industrial | ins | 00.20.20 | Elements d'entorn urbà preexistent
22 x ind | [ind] indústria | indústria | ind | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric
ind | [ind] indústria | indústria | ind | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Dapsa; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: indústria; ACAT_L2-DescripcioLocalitzacio: Dapsa
5 x flu | [flu] curs fluvial | curs fluvial | flu | 00.20.20 | Elements d'entorn urbà preexistent | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: l'Ebre; ICGC_A40_Entorn: gen; ICGC_A41_EntornDescripcio: cas genèric; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: curs fluvial; ACAT_L2-DescripcioLocalitzacio: l'Ebre
4 x flu | [flu] curs fluvial | curs fluvial | flu | 00.20.20 | Elements d'entorn urbà preexistent | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: l'Ebre; ICGC_A40_Entorn: cnx; ICGC_A41_EntornDescripcio: connexió; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: curs fluvial; ACAT_L2-DescripcioLocalitzacio: l'Ebre
pja | [pja] recinte de prats, jardins, arbrat i instal·lacions per a l'esbarjo | recinte de prats, jardins, arbrat i instal·lacions per a l'esbarjo | pja | 00.20.20 | Elements d'entorn urbà preexistent
36 x esr | [esr] esplanada amb revestiment | esplanada amb revestiment | esr | 00.20.20 | Elements d'entorn urbà preexistent
esp | [esp] recinte d'inst. esportiva | recinte d'inst. esportiva | esp | 00.20.20 | Elements d'entorn urbà preexistent | ICGC_Identificacio - ICGC_D10_Nom: Zona esportiva Municipal; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: recinte d'inst. esportiva; ACAT_L2-DescripcioLocalitzacio: Zona esportiva Municipal
144 x esn | [esn] esplanada sense revestiment | esplanada sense revestiment | esn | 00.20.20 | Elements d'entorn urbà preexistent
11 x emb | [emb] embarcador | embarcador | emb | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric
6 x ele | [ele] torre elèctrica | torre elèctrica | ele | 00.20.10 | Edificacions colindants preexistents
ele | [ele] torre elèctrica | torre elèctrica | ele | 00.20.20 | Elements d'entorn urbà preexistent
15 x hiv | [hiv] hivernacle | hivernacle | hiv | 00.20.10 | Edificacions colindants preexistents
3 x mob | [mob] moll, espigó d'obra | moll, espigó d'obra | mob | 00.20.20 | Elements d'entorn urbà preexistent | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric
com | [com] torre de comunicacions | torre de comunicacions | com | 00.20.10 | Edificacions colindants preexistents
13 x cns | [cns] construcció | construcció | cns | 00.20.20 | Elements d'entorn urbà preexistent | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric
cns | [cns] construcció | construcció | cns | 00.20.20 | Elements d'entorn urbà preexistent | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Torre de la Candela; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: construcció; ACAT_L2-DescripcioLocalitzacio: Torre de la Candela
cem | [cem] recinte de cementiri | recinte de cementiri | cem | 00.20.20 | Elements d'entorn urbà preexistent | ICGC_Identificacio - ICGC_D10_Nom: Cementiri d'Amposta; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: recinte de cementiri; ACAT_L2-DescripcioLocalitzacio: Cementiri d'Amposta
4 x lpn | [lpn] lateral de pont | lateral de pont | lpn | 00.20.20 | Elements d'entorn urbà preexistent | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Pont de l'Autopista; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: lateral de pont; ACAT_L2-DescripcioLocalitzacio: Pont de l'Autopista
80 x lpn | [lpn] lateral de pont | lateral de pont | lpn | 00.20.20 | Elements d'entorn urbà preexistent | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric
4 x lpn | [lpn] lateral de pont | lateral de pont | lpn | 00.20.20 | Elements d'entorn urbà preexistent | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Pont de la Carretera Nacional; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: lateral de pont; ACAT_L2-DescripcioLocalitzacio: Pont de la Carretera Nacional
2 x lpn | [lpn] lateral de pont | lateral de pont | lpn | 00.20.20 | Elements d'entorn urbà preexistent | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Pont Penjat; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: lateral de pont; ACAT_L2-DescripcioLocalitzacio: Pont Penjat
344 x ill | [ill] illa urbanitzada | illa urbanitzada | ill | 00.20.20 | Elements d'entorn urbà preexistent
5 x bsc | [bsc] bosc | bosc | bsc | 70.50.10.10 | Arbrats
45 x bas | [bas] bassa | bassa | bas | 00.20.20 | Elements d'entorn urbà preexistent
8 x can | [can] canal, rec, séquia | canal, rec, séquia | can | ICGC_Identificacio - ICGC_A30_Estat: cns; ICGC_A31_EstatDescripcio: en construcció; ICGC_A40_Entorn: gen; ICGC_A41_EntornDescripcio: cas genèric
18 x can | [can] canal, rec, séquia | canal, rec, séquia | can | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Canal de la Dreta de l'Ebre; ICGC_A40_Entorn: gen; ICGC_A41_EntornDescripcio: cas genèric; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: canal, rec, séquia; ACAT_L2-DescripcioLocalitzacio: Canal de la Dreta de l'Ebre
7 x can | [can] canal, rec, séquia | canal, rec, séquia | can | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_A40_Entorn: gen; ICGC_A41_EntornDescripcio: cas genèric
17 x can | [can] canal, rec, séquia | canal, rec, séquia | can | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Canal de la Dreta de l'Ebre; ICGC_A40_Entorn: cnx; ICGC_A41_EntornDescripcio: connexió; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: canal, rec, séquia; ACAT_L2-DescripcioLocalitzacio: Canal de la Dreta de l'Ebre
9 x can | [can] canal, rec, séquia | canal, rec, séquia | can | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Canal de l'Esquerra de l'Ebre; ICGC_A40_Entorn: gen; ICGC_A41_EntornDescripcio: cas genèric; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: canal, rec, séquia; ACAT_L2-DescripcioLocalitzacio: Canal de l'Esquerra de l'Ebre
6 x can | [can] canal, rec, séquia | canal, rec, séquia | can | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Canal Nou de Camarles; ICGC_A40_Entorn: cnx; ICGC_A41_EntornDescripcio: connexió; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: canal, rec, séquia; ACAT_L2-DescripcioLocalitzacio: Canal Nou de Camarles
8 x can | [can] canal, rec, séquia | canal, rec, séquia | can | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Canal de l'Esquerra de l'Ebre; ICGC_A40_Entorn: cnx; ICGC_A41_EntornDescripcio: connexió; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: canal, rec, séquia; ACAT_L2-DescripcioLocalitzacio: Canal de l'Esquerra de l'Ebre
6 x can | [can] canal, rec, séquia | canal, rec, séquia | can | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Canal Nou de Camarles; ICGC_A40_Entorn: gen; ICGC_A41_EntornDescripcio: cas genèric; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: canal, rec, séquia; ACAT_L2-DescripcioLocalitzacio: Canal Nou de Camarles
3 x can | [can] canal, rec, séquia | canal, rec, séquia | can | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_A40_Entorn: cnx; ICGC_A41_EntornDescripcio: connexió
can | [can] canal, rec, séquia | canal, rec, séquia | can | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Canal Marítim; ICGC_A40_Entorn: gen; ICGC_A41_EntornDescripcio: cas genèric; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: canal, rec, séquia; ACAT_L2-DescripcioLocalitzacio: Canal Marítim
27 x aga | [aga] agrupació d'arbres | agrupació d'arbres | aga | 70.50.10.10 | Arbrats
18 x veg | [veg] tanca de vegetació | tanca de vegetació | veg | 00.20.20 | Elements d'entorn urbà preexistent
746 x edi | [edi] edificació | edificació | edi | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric
edi | [edi] edificació | edificació | edi | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Hopistal Comarcal d'Amposta; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: edificació; ACAT_L2-DescripcioLocalitzacio: Hopistal Comarcal d'Amposta
edi | [edi] edificació | edificació | edi | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: rui; ICGC_A31_EstatDescripcio: en ruïnes; ICGC_D10_Nom: Mas de Josep d'Estorac; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: edificació; ACAT_L2-DescripcioLocalitzacio: Mas de Josep d'Estorac
edi | [edi] edificació | edificació | edi | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Institut Ramon Berenguer IV; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: edificació; ACAT_L2-DescripcioLocalitzacio: Institut Ramon Berenguer IV
edi | [edi] edificació | edificació | edi | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Mas de Llorente; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: edificació; ACAT_L2-DescripcioLocalitzacio: Mas de Llorente
edi | [edi] edificació | edificació | edi | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Molí de Calatrava; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: edificació; ACAT_L2-DescripcioLocalitzacio: Molí de Calatrava
edi | [edi] edificació | edificació | edi | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: rui; ICGC_A31_EstatDescripcio: en ruïnes; ICGC_D10_Nom: Mas del Viu; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: edificació; ACAT_L2-DescripcioLocalitzacio: Mas del Viu
15 x edi | [edi] edificació | edificació | edi | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: rui; ICGC_A31_EstatDescripcio: en ruïnes
edi | [edi] edificació | edificació | edi | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: el Partidor; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: edificació; ACAT_L2-DescripcioLocalitzacio: el Partidor
3 x edi | [edi] edificació | edificació | edi | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: cns; ICGC_A31_EstatDescripcio: en construcció
edi | [edi] edificació | edificació | edi | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Consell Comarcal del Montsià; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: edificació; ACAT_L2-DescripcioLocalitzacio: Consell Comarcal del Montsià
edi | [edi] edificació | edificació | edi | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Mas Miralles; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: edificació; ACAT_L2-DescripcioLocalitzacio: Mas Miralles
edi | [edi] edificació | edificació | edi | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Institut Montsià; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: edificació; ACAT_L2-DescripcioLocalitzacio: Institut Montsià
edi | [edi] edificació | edificació | edi | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Centre Cultural; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: edificació; ACAT_L2-DescripcioLocalitzacio: Centre Cultural
edi | [edi] edificació | edificació | edi | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Escola Soriano Montagut; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: edificació; ACAT_L2-DescripcioLocalitzacio: Escola Soriano Montagut
edi | [edi] edificació | edificació | edi | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Masia Pepion; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: edificació; ACAT_L2-DescripcioLocalitzacio: Masia Pepion
edi | [edi] edificació | edificació | edi | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Museu de les Terres de l'Ebre; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: edificació; ACAT_L2-DescripcioLocalitzacio: Museu de les Terres de l'Ebre
edi | [edi] edificació | edificació | edi | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Masies de Burjassénia; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: edificació; ACAT_L2-DescripcioLocalitzacio: Masies de Burjassénia
edi | [edi] edificació | edificació | edi | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Escola Mestre Agustí Barberà; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: edificació; ACAT_L2-DescripcioLocalitzacio: Escola Mestre Agustí Barberà
edi | [edi] edificació | edificació | edi | 00.20.10 | Edificacions colindants preexistents | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric; ICGC_D10_Nom: Mercat Municipal; ACAT_Localitzacio - ACAT_L1-CodiLocalitzacio: edificació; ACAT_L2-DescripcioLocalitzacio: Mercat Municipal
2 x mol | [mol] moll, espigó d'acumulació de blocs de pedra o formigó | moll, espigó d'acumulació de blocs de pedra o formigó | mol | 00.20.20 | Elements d'entorn urbà preexistent | ICGC_Identificacio - ICGC_A30_Estat: gen; ICGC_A31_EstatDescripcio: cas genèric
abo | [abo] abocador | abocador | abo | 00.20.20 | Elements d'entorn urbà preexistent
41 x fil | [fil] filat | filat | fil | 00.20.20 | Elements d'entorn urbà preexistent
sol | [sol] terreny | terreny | sol | ICGC_Identificacio - sets with these values: 12; ACAT_Identificacio - sets with these values: 12
21 x dmt | [dmt] desmunt | desmunt | dmt | 00.20.20 | Elements d'entorn urbà preexistent
148 x prt | [prt] parterre | parterre | prt | 70.50.20 | Parterres
14 x dip | [dip] dipòsit cobert | dipòsit cobert | dip | 00.20.20 | Elements d'entorn urbà preexistent
ped | [ped] pedrera, mina a cel obert | pedrera, mina a cel obert | ped | 00.20.20 | Elements d'entorn urbà preexistent
7 x fut | [fut] pista d'un camp de futbol | pista d'un camp de futbol | fut | 00.20.20 | Elements d'entorn urbà preexistent
